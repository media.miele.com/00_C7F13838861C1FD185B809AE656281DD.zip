Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: b82956f7-cf3c-4d82-a613-c963d3a4fa9d, NumberOfSaves: 1]
File name: 0001
Time: 2026-02-27T08:25:01+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13058210_CH_ODC1204LBL:331M0CDL_CH_13058210_ODC1204LBL, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Material: z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Gas, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Water_OUT, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - Reference: 331M0CDL_CH_13058210_ODC1204LBL; sets with these values: 2
